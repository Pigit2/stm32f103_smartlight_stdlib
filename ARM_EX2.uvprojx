# Keil uVision project ARM_EX2.uvprojx, settings and files
target EX1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EX1 +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\APP;.\CMSIS\CoreSupport;.\CMSIS\DeviceSupport\ST\STM32F10x\startup;.\STM32F10x_StdPeriph_Driver\inc;.\Others\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group APP
    ./APP/: stm32f10x_it.c system_stm32f10x.c ARM_EX1.C
  group StdLib
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./CMSIS/CoreSupport/: core_cm3.c
    ./CMSIS/DeviceSupport/ST/STM32F10x/startup/: startup_stm32f10x_hd.s
  group Others
    ./Others/src/: delay.c oled.c sys.c cJSON.c hwiot.c usart.c led.c adc.c rtc.c key.c tim.c
software components: CMSIS:CORE 5.6.0
